## Config.in
```kconfig
menu "cmt"
    config BR2_PACKAGE_CMT
        bool "cmt"
        help
            Char mem test
endmenu
```
